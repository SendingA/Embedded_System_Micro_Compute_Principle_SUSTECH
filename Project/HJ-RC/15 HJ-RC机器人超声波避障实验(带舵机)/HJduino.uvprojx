# Keil uVision project HJduino.uvprojx, settings and files
target HJduino (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HJduino +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\Libraries\CMSIS;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\STM32F10x_StdPeriph_Driver;.\User;.\APP\led;.\APP\key;.\Public;.\APP\exti;.\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;.\SYSTEM\motor;.\SYSTEM\IRSEARCH;.\SYSTEM\keysacn;.\SYSTEM\Server;.\SYSTEM\TIMER;.\SYSTEM\IRAvoid;.\SYSTEM\UltrasonicWave;.\SYSTEM\USART2;.\SYSTEM\remote
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ./User/: main.c stm32f10x_it.c
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_exti.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ./Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group Startup
    ./Libraries/CMSIS/: startup_stm32f10x_hd.s
  group APP
    ./APP/exti/: exti.c
  group Public
    ./Public/: system.c
  group SYSTEM
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/usart/: usart.c
    ./SYSTEM/motor/: motor.c
    ./SYSTEM/IRSEARCH/: IRSEARCH.c
    ./SYSTEM/keysacn/: keysacn.c
    ./SYSTEM/Server/: Server.c
    ./SYSTEM/TIMER/: timer.c
    ./SYSTEM/IRAvoid/: IRAvoid.c
    ./SYSTEM/UltrasonicWave/: UltrasonicWave.c
    ./SYSTEM/remote/: remote.c
    ./SYSTEM/USART2/: usart2.c
